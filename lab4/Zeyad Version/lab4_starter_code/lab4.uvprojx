# Keil uVision project lab4.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lab4
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __RTGT_UART
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./src/: lfsr113.c random.c Retarget.c uart.c random.h main.c
  group sourceCode
    ./src/: lfsr113.c random.c Retarget.c uart.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Device:Startup 1.0.0
